# Keil uVision project nuc029tan_demo.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: NUC029TAN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.11
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: nuc029tan_demo
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\StdDriver\inc;.\User;.\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group User
    ./User/: main.c startup_NUC029xAN.s system_NUC029xAN.c systick.c Flash.c Usart0.c
  group StdDriver
    ./StdDriver/src/: acmp.c adc.c clk.c ebi.c fmc.c gpio.c i2c.c pwm.c retarget.c spi.c sys.c timer.c uart.c wdt.c wwdt.c
